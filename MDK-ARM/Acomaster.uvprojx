# Keil uVision project Acomaster.uvprojx, settings and files
target ACOMASTER (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Acomaster +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;./Software;./Hardware;./Devices;./Devices/adau1701;./Devices/adau1761;.\Software\wouo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c rtc.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Hardware
    ./Hardware/: simi2c.c timer.c key.c led.c eeprom.c multi_button.c
  group Software
    ./Software/: pwr_mngr.c gui.c sys_init.c audio.c tasks.c
  group Devices
    ./Devices/: cw2015.c cs43131.c oled.c qcc5125.c oledfont.c
    ./Devices/adau1761/: adau1761.c
  group wouo
    ./Software/wouo/: WouoUI.c WouoUI_font.c WouoUI_oled.c WouoUI_page.c WouoUI_port.c WouoUI_user.c WouoUI_widget.c WouoUI_win.c WouoUI_udp.c
software components: CMSIS:CORE 5.6.0
